
module m ;
	reg r1;
endmodule

