
module M1 ;
	wire w2;
endmodule

